Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8ded863a-fef2-49e7-b83e-72eb26fb6669, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 4749(2024).ifc
Time: 2025-01-29T21:54:11
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_352786_4
InPort_352786_5

# IfcFlowController: 4749(2024):4749 Bath and shower faucet with shower set, 4749(2024):4749 Bath and shower faucet with shower set:352786
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 4749(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC010862 Bath mixing tap; LVI Number: 6310920; Noise Class: I (ISO 3822); NRF Number: 1365161; RSK Number: 8283477; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4749; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/198283_4749_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/4749; VVS Number: 722258804
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Flexible length / can be shortened;Anti-twist hose connector; Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread;Cover plate(s); Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.16 dm3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.33 dm3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Installation Width: 150 ± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 200000 Pa; Pressure Loss With Flow 03ls: 255000 Pa; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1750 mm);Variable fixing points;Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Pulsating - Strong water stream for massage or body treatment;Intense - invigorating water stream;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Spout Projection: 180 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Thermostatic temperature control; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - FaucetNominalDepth: 185 mm; FaucetNominalHeight: 60 mm; FaucetNominalWidth: 299.5 mm; HandShowerNominalDepth: 172.2 mm; HandShowerNominalHeight: 766.4 mm; HandShowerNominalWidth: 241 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/4749; Catalog Drawing URL: http://static.oras.com/catdrw/4749; Category B2C: Bathtub & Shower; Color variants: 4749-33;4749-80;4749-81; Dimension Drawing URL: http://static.oras.com/dimdrw/4749; FDV Document URL: http://www.oras.com/datasheet/4749/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4749; Group: BathAndShowerFaucetsWithShowerSet; Installation and Maintenance Guide URL: http://static.oras.com/manual/4749; Interactive AR View URL: https://static.oras.com/AR/4749; Long Marketing: Oras Aurelia. A Harmony of Simplicity and Elegance. The timeless silhouette of an ancient, handcrafted bridge, perfectly mirrored in tranquil waters, evolves into a slender and elegant cylindric thermostat. Meticulously designed handles seamlessly complete the form without compromising functionality, exuding elegance from every angle. The perfect designed handles completing the design with out losing its functionality. It becomes easy with simple, in few movement to adjust flow and temperature for your decried settings for the perfect shower experience. AURELIA draws design inspiration from the exquisite elements of wild nature. From the graceful Lotus flower transformed into a spray face, designed for pure enjoyment, to the simplest curve of a tiny waterdrop. . 110mm – 3 spray face Handshower Easy push diverter for simple selection of spray face Easy to adjust shower holder ELEVATING YOUR MOMENTS; Manufacturer: Oras; Market: Denmark;Estonia;International;Lithuania;Latvia;Norway;Poland;Sweden; Mobile Product Information URL: http://mpi.oras.com/4749; Model: 4749 Bath and shower faucet with shower set; Name_en: 4749 Bath and shower faucet with shower set; OmniClass Number: 23.45.55.00; Product Code: 4749; Product Family: Oras Aurelia; Product Image URL: http://static.oras.com/image/4749; Product URL: http://static.oras.com/4749; Technical DataSheet URL: http://www.oras.com/datasheet/4749/en; Type Name: 4749 Bath and shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4749(2024); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 4749; Name: 4749 Bath and shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x90x65 mm; Shower:220x140x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 4749; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 4749 Bath and shower faucet with shower set
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 4749 Bath and shower faucet with shower set; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 300 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerVisibility: yes; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm; ShowerDefaultElevation: 1200 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.448963 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 160 mm; OutletAngle: 0 deg; Volume: 0.0355582 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4749(2024); Family and Type: 4749(2024): 4749 Bath and shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4749 Bath and shower faucet with shower set; Type Id: 352762; WarrantyStartDate: n/a
